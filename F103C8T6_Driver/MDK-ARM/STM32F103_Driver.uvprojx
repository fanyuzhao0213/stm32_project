# Keil uVision project STM32F103_Driver.uvprojx, settings and files
target STM32F103_Driver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F103_Driver +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../HardWare/CAN;../HardWare/KEY;../HardWare/OLED;../HardWare/SEGGER_RTT;../HardWare/SOFT_IIC;..\HardWare\SOFT_SPI;..\HardWare\W25Q128;..\HardWare\NRF_24L01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../HardWare/SOFT_IIC/: soft_iic.c
    ../Core/Src/: main.c gpio.c can.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group HardWare
    ../HardWare/CAN/: my_can.c
    ../HardWare/KEY/: my_key.c
    ../HardWare/OLED/: OLED.c OLED_Data.c
    ../HardWare/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../HardWare/SOFT_SPI/: soft_spi.c
    ../HardWare/W25Q128/: W25Q128.c
    ../HardWare/NRF_24L01/: NRF24L01.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
